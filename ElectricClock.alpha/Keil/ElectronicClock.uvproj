# Keil uVision project ElectronicClock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ElectronicClock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Source/: DS1302.h LCD1602.h main.h DS1302.c LCD1602.c main.c
